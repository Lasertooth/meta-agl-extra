# https://bugzilla.yoctoproject.org/show_bug.cgi?id=10858
SYSTEMD_AUTO_ENABLE = "disable"

